# Keil uVision project lhl_car.uvprojx, settings and files
target lhl_car (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: lhl_car +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../gmcode
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal_adc.h stm32f4xx_hal.h stm32_assert_template.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_cec.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_exti.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_fmpsmbus.h stm32f4xx_hal_fmpsmbus_ex.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_smbus.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fmpi2c.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group gmcode
    ../gmcode/: led.c led.h key.c key.h adc_dma.h adc_dma.c myserial.c myserial.h motor.h msg.h msg.c buzzer.c motor.c extre.h buzzer.h extre.c kinematic.c kinematic.h
software components: CMSIS:CORE 6.1.1
